/*
 * oled.c — Driver mínimo para OLED 128x64 por I2C.
 * Usa direccionamiento por páginas, que funciona tanto en SSD1306 como en SH1106.
 * Si tu pantalla es SH1106 (1,3") y la imagen sale corrida 2 columnas,
 * cambia OLED_COL_OFFSET a 2.
 */
#include "oled.h"
#include "i2c_bus.h"
#include "board.h"
#include <string.h>
#include "esp_log.h"

#define OLED_W 128
#define OLED_H 64
#define OLED_PAGES (OLED_H / 8)
#define OLED_COL_OFFSET 0

static const char *TAG = "oled";
static i2c_master_dev_handle_t s_dev;
static bool s_present;
static uint8_t s_fb[OLED_PAGES][OLED_W];

/* Fuente 5x7 clásica, ASCII 0x20..0x7E. El carácter 0x7F se usa como '°'. */
static const uint8_t FONT5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00},{0x00,0x00,0x5F,0x00,0x00},{0x00,0x07,0x00,0x07,0x00},{0x14,0x7F,0x14,0x7F,0x14}, /*  !"# */
    {0x24,0x2A,0x7F,0x2A,0x12},{0x23,0x13,0x08,0x64,0x62},{0x36,0x49,0x56,0x20,0x50},{0x00,0x05,0x03,0x00,0x00}, /* $%&' */
    {0x00,0x1C,0x22,0x41,0x00},{0x00,0x41,0x22,0x1C,0x00},{0x14,0x08,0x3E,0x08,0x14},{0x08,0x08,0x3E,0x08,0x08}, /* ()*+ */
    {0x00,0x50,0x30,0x00,0x00},{0x08,0x08,0x08,0x08,0x08},{0x00,0x60,0x60,0x00,0x00},{0x20,0x10,0x08,0x04,0x02}, /* ,-./ */
    {0x3E,0x51,0x49,0x45,0x3E},{0x00,0x42,0x7F,0x40,0x00},{0x42,0x61,0x51,0x49,0x46},{0x21,0x41,0x45,0x4B,0x31}, /* 0123 */
    {0x18,0x14,0x12,0x7F,0x10},{0x27,0x45,0x45,0x45,0x39},{0x3C,0x4A,0x49,0x49,0x30},{0x01,0x71,0x09,0x05,0x03}, /* 4567 */
    {0x36,0x49,0x49,0x49,0x36},{0x06,0x49,0x49,0x29,0x1E},{0x00,0x36,0x36,0x00,0x00},{0x00,0x56,0x36,0x00,0x00}, /* 89:; */
    {0x08,0x14,0x22,0x41,0x00},{0x14,0x14,0x14,0x14,0x14},{0x00,0x41,0x22,0x14,0x08},{0x02,0x01,0x51,0x09,0x06}, /* <=>? */
    {0x32,0x49,0x79,0x41,0x3E},{0x7E,0x11,0x11,0x11,0x7E},{0x7F,0x49,0x49,0x49,0x36},{0x3E,0x41,0x41,0x41,0x22}, /* @ABC */
    {0x7F,0x41,0x41,0x22,0x1C},{0x7F,0x49,0x49,0x49,0x41},{0x7F,0x09,0x09,0x09,0x01},{0x3E,0x41,0x49,0x49,0x7A}, /* DEFG */
    {0x7F,0x08,0x08,0x08,0x7F},{0x00,0x41,0x7F,0x41,0x00},{0x20,0x40,0x41,0x3F,0x01},{0x7F,0x08,0x14,0x22,0x41}, /* HIJK */
    {0x7F,0x40,0x40,0x40,0x40},{0x7F,0x02,0x0C,0x02,0x7F},{0x7F,0x04,0x08,0x10,0x7F},{0x3E,0x41,0x41,0x41,0x3E}, /* LMNO */
    {0x7F,0x09,0x09,0x09,0x06},{0x3E,0x41,0x51,0x21,0x5E},{0x7F,0x09,0x19,0x29,0x46},{0x46,0x49,0x49,0x49,0x31}, /* PQRS */
    {0x01,0x01,0x7F,0x01,0x01},{0x3F,0x40,0x40,0x40,0x3F},{0x1F,0x20,0x40,0x20,0x1F},{0x3F,0x40,0x38,0x40,0x3F}, /* TUVW */
    {0x63,0x14,0x08,0x14,0x63},{0x07,0x08,0x70,0x08,0x07},{0x61,0x51,0x49,0x45,0x43},{0x00,0x7F,0x41,0x41,0x00}, /* XYZ[ */
    {0x02,0x04,0x08,0x10,0x20},{0x00,0x41,0x41,0x7F,0x00},{0x04,0x02,0x01,0x02,0x04},{0x40,0x40,0x40,0x40,0x40}, /* \]^_ */
    {0x00,0x01,0x02,0x04,0x00},{0x20,0x54,0x54,0x54,0x78},{0x7F,0x48,0x44,0x44,0x38},{0x38,0x44,0x44,0x44,0x20}, /* `abc */
    {0x38,0x44,0x44,0x48,0x7F},{0x38,0x54,0x54,0x54,0x18},{0x08,0x7E,0x09,0x01,0x02},{0x0C,0x52,0x52,0x52,0x3E}, /* defg */
    {0x7F,0x08,0x04,0x04,0x78},{0x00,0x44,0x7D,0x40,0x00},{0x20,0x40,0x44,0x3D,0x00},{0x7F,0x10,0x28,0x44,0x00}, /* hijk */
    {0x00,0x41,0x7F,0x40,0x00},{0x7C,0x04,0x18,0x04,0x78},{0x7C,0x08,0x04,0x04,0x78},{0x38,0x44,0x44,0x44,0x38}, /* lmno */
    {0x7C,0x14,0x14,0x14,0x08},{0x08,0x14,0x14,0x18,0x7C},{0x7C,0x08,0x04,0x04,0x08},{0x48,0x54,0x54,0x54,0x20}, /* pqrs */
    {0x04,0x3F,0x44,0x40,0x20},{0x3C,0x40,0x40,0x20,0x7C},{0x1C,0x20,0x40,0x20,0x1C},{0x3C,0x40,0x30,0x40,0x3C}, /* tuvw */
    {0x44,0x28,0x10,0x28,0x44},{0x0C,0x50,0x50,0x50,0x3C},{0x44,0x64,0x54,0x4C,0x44},{0x00,0x08,0x36,0x41,0x00}, /* xyz{ */
    {0x00,0x00,0x7F,0x00,0x00},{0x00,0x41,0x36,0x08,0x00},{0x10,0x08,0x08,0x10,0x08},{0x00,0x06,0x09,0x09,0x06}, /* |}~° */
};

_Static_assert(sizeof(FONT5x7) / sizeof(FONT5x7[0]) == 96, "la fuente debe cubrir 0x20..0x7F");

static esp_err_t cmd(const uint8_t *c, size_t n)
{
    uint8_t buf[8];
    buf[0] = 0x00;                         /* byte de control: comandos */
    memcpy(&buf[1], c, n);
    return i2c_master_transmit(s_dev, buf, n + 1, 100);
}

esp_err_t oled_init(void)
{
    if (!i2c_bus_probe(OLED_ADDR)) {
        ESP_LOGW(TAG, "No se detectó pantalla en 0x%02X (es opcional)", OLED_ADDR);
        return ESP_ERR_NOT_FOUND;
    }
    esp_err_t e = i2c_bus_add_device(OLED_ADDR, &s_dev);
    if (e != ESP_OK) return e;

    static const uint8_t seq[][3] = {
        {1, 0xAE},             /* apagar                       */
        {2, 0xD5, 0x80},       /* reloj                        */
        {2, 0xA8, 0x3F},       /* multiplex 64                 */
        {2, 0xD3, 0x00},       /* offset vertical              */
        {1, 0x40},             /* línea de inicio              */
        {2, 0x8D, 0x14},       /* bomba de carga (SSD1306)     */
        {1, 0xA1},             /* espejo horizontal            */
        {1, 0xC8},             /* espejo vertical              */
        {2, 0xDA, 0x12},       /* pines COM                    */
        {2, 0x81, 0xCF},       /* contraste                    */
        {2, 0xD9, 0xF1},       /* precarga                     */
        {2, 0xDB, 0x40},       /* VCOMH                        */
        {1, 0xA4},             /* mostrar RAM                  */
        {1, 0xA6},             /* normal (no invertido)        */
        {1, 0xAF},             /* encender                     */
    };
    for (size_t i = 0; i < sizeof(seq) / sizeof(seq[0]); i++) {
        e = cmd(&seq[i][1], seq[i][0]);
        if (e != ESP_OK) return e;
    }
    s_present = true;
    oled_clear();
    oled_flush();
    ESP_LOGI(TAG, "Pantalla OLED lista");
    return ESP_OK;
}

bool oled_present(void) { return s_present; }

void oled_clear(void) { memset(s_fb, 0, sizeof(s_fb)); }

void oled_text(int col, int row, const char *s)
{
    if (row < 0 || row >= OLED_PAGES) return;
    int x = col * 6;
    for (; *s && x + 5 <= OLED_W; s++, x += 6) {
        unsigned char c = (unsigned char)*s;
        if (c == '~') c = 0x7F;                     /* símbolo de grados */
        if (c < 0x20 || c > 0x7F) c = '?';
        memcpy(&s_fb[row][x], FONT5x7[c - 0x20], 5);
        s_fb[row][x + 5] = 0;
    }
}

void oled_invert_row(int row)
{
    if (row < 0 || row >= OLED_PAGES) return;
    for (int x = 0; x < OLED_W; x++) s_fb[row][x] ^= 0xFF;
}

esp_err_t oled_flush(void)
{
    if (!s_present) return ESP_ERR_INVALID_STATE;
    uint8_t buf[OLED_W + 1];
    for (int p = 0; p < OLED_PAGES; p++) {
        const uint8_t addr[3] = {
            (uint8_t)(0xB0 | p),
            (uint8_t)(0x00 | (OLED_COL_OFFSET & 0x0F)),
            (uint8_t)(0x10 | (OLED_COL_OFFSET >> 4)),
        };
        esp_err_t e = cmd(addr, 3);
        if (e != ESP_OK) return e;
        buf[0] = 0x40;                       /* byte de control: datos */
        memcpy(&buf[1], s_fb[p], OLED_W);
        e = i2c_master_transmit(s_dev, buf, sizeof(buf), 200);
        if (e != ESP_OK) return e;
    }
    return ESP_OK;
}
